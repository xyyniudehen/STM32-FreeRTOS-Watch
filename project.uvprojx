# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  AfterMake: fromelf --bin --output .\Objects\APP.bin .\Objects\project.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\start;.\user;.\user;.\Library;.\System;.\hardware;.\FREERTOS\FreeRTOS-Kernel\include;.\FREERTOS\FreeRTOS-Kernel\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start
    ./start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h Timer.c Timer.h Serial.c Serial.h
  group hardware
    ./hardware/: LED.c LED.h KEY.c KEY.h OLED.c OLED.h OLED_Font.h MyRTC.c MyRTC.h OLED_Data.c OLED_Data.h menu.c menu.h SetTime.c SetTime.h MPU6050.c MPU6050.h MPU6050_Reg.h MyI2C.c MyI2C.h dino.c dino.h AD.c AD.h Power.c Power.h Alarm.c Alarm.h
  group user
    ./user/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h FreeRTOSConfig.h
  group FreeRTOS
    ./FREERTOS/FreeRTOS-Kernel/: event_groups.c list.c queue.c tasks.c timers.c
    ./FREERTOS/FreeRTOS-Kernel/portable/RVDS/ARM_CM3/: port.c
    ./FREERTOS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
